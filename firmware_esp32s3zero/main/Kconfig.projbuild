## firmware_esp32s3zero/main/Kconfig.projbuild
```kconfig
menu "DoorBell Configuration"

    # All configuration is now managed dynamically via NVS
    # and the Admin Web Interface.

endmenu
```
